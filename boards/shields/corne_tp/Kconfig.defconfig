## dts/bindings/behaviors/zmk,behavior-uf2-reset.yaml
```yaml
description: UF2 Bootloader Reset Behavior

compatible: "zmk,behavior-uf2-reset"

include: one_param.yaml
```
